# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Timer0.c Tmier0.h key.c key.h timer0.h
    E:/51单片机/模块化编程/: delay.c delay.h ledlsd.c ledlsd.h
