# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: AT24C02.c AT24C02.h main.c LCD1602.c LCD1602.h delay.c delay.h INT0.c INT0.h IR.c IR.h Timer0.c Timer0.h DS18B20.c DS18B20.h oneWire.c oneWire.h Uart.c Uart.h I2C.c I2C.h
